# Repository shetevaibhav014/LDO-3.3V-AMS1117

## KiCad design AMS1117_LDO.kicad_pcb

Parts:
C1, C3: 10uF; C_1206_3216Metric
C2, C4: 0.1uF; C_0603_1608Metric
D1: LED; LED_1206_3216Metric
J1, J2: Screw_Terminal_01x02; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
R1: 2k2; R_1206_3216Metric
U1: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
GND: C1.2, C2.2, C3.2, C4.2, D1.1 (K), J1.1, J2.2, U1.1 (GND)
INPUT: C1.1, C2.1, J1.2, R1.1, U1.3 (VI)
unnamed: D1.2 (A), R1.2
OUTPUT: C3.1, C4.1, J2.1, U1.2 (VO)

Notes on the sheet:
DC/IN 12V
LDO
DC/OUT 3V3

Board: 2 copper layers, 49.0 x 25.0 mm, 9 parts (0 on the bottom side), 4 nets.

File BOM/BOM.csv:

"Reference","Qty","Value","DNP","Exclude from BOM","Exclude from Board","Footprint","Datasheet"
"C1,C3","2","10uF","","","","Capacitor_SMD:C_1206_3216Metric","~"
"C2,C4","2","0.1uF","","","","Capacitor_SMD:C_0603_1608Metric","~"
"D1","1","LED","","","","LED_SMD:LED_1206_3216Metric","~"
"J1,J2","2","Screw_Terminal_01x02","","","","TerminalBlock:TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm","~"
"R1","1","2k2","","","","Resistor_SMD:R_1206_3216Metric","~"
"U1","1","AMS1117-3.3","","","","Package_TO_SOT_SMD:SOT-223-3_TabPin2","http://www.advanced-monolithic.com/pdf/ds1117.pdf"
